//TODO 
//
//- 
//-

/* MAIN BASE CANNING
 * 17/8/18
 * 
 * MEGA CON ETHERNET SHIELD, BOTONES, I2C DISPLAY
 * SE COMUNICA POR MQTT A EL RESTO DE LA RED
 * 
 * 
 * 
 * 1.0 alpha
 */
 
/********************************PRE-SETUP***********************************/
//INCLUDES
#include <SPI.h>
#include <Ethernet.h>
#include <PubSubClient.h>
#include <Wire.h>
#include <LiquidCrystal_I2C.h>
#include "SoftwareSerial.h"
#include "DFRobotDFPlayerMini.h"
////DEFINES ESTRUCTURALES/////
#define NULO  0
#define BOTON 1
#define IMAN  1
#define ETH   2
#define ANA   3
////DEFINES EDITABLES ////////
#define RX_ADF  2
#define TX_ADF  3
#define BOTON_NEXT  22
#define BOTON_RESET 23
#define DELAY_BOTON 500 //en ms
//EDITABLE
const int NUM_PASOS = 10;
const int TIPO_PASOS [NUM_PASOS] = { IMAN , IMAN, ETH , ETH , IMAN , IMAN , IMAN , ETH , IMAN , IMAN}; // 0 nulo, 1 boton o iman, 2 ethernet, 3 analog
const int PASOS_SIMULTANEOS [NUM_PASOS] = {0,0,0,0,0,0,0,0,0,0}; //indica si hay si hay pasos simultaneos y cuantos 
const int NUM_ETH_CORE = 4;
const int NUM_ETH_EXTRA = 1;
const int RELE_NUM = 14;
const int RELE_POS [RELE_NUM] = {29,28,27,26,25,24,23,22,30,31,32,33,34,35};
const int SENSORES_NUM = 7;
const int SENSORES_POS [SENSORES_NUM] = {36,37,38,39,40,41,42}; //pines donde se encuentran los sensores, 0 en posicion donde no 
const int SENSORES_PULL [SENSORES_NUM] = {HIGH , HIGH , HIGH, HIGH, HIGH , HIGH, HIGH};
const boolean HOW_TO_CHECK [SENSORES_NUM] = {0 , 0 , 0 , 0 , 0 , 0 , 0}; //true en estado bajo o alto? (0 o 1)
const String MENSAJES_LCD [] { //Los primeros 3 estan reservados, el resto a eleccon del juego
  
  "Bienvenido a    ",//Mensaje de Bienvenida
  "La purga        ",//Nombre del juego
  "Ordenando       ",//Ordenando
  "Listo           ",//fin de orden 
  "1:Silla         ",
  "2:Lavarropas    ", 
  "3:Tablero       ",
  "4:Teclado       ",
  "5:Chimenea      ",
  "6:Mascaras      ", 
  "7:Portero       ",
  "8:Linterna      ",
  "9:Barreta       ",  
  "JUEGO FINALIZADO",
   
};
///////////OBLIGATORIAMENTE EDITABLE///////////////////
const char* topicName = "main";                      //topic
IPAddress mqtt_server(192, 168, 0, 100);             //IP del servidor
byte mac[] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 }; //mac
int puerto_server = 1883;
String CLIENT_ID = "Main_01";
////////////NO EDITABLE///////////////////
boolean estado_act [NUM_PASOS];   //array para los pasos resueltos
int sensores_act [SENSORES_NUM];  //array para estado actual de sensores
int sensores_check_lugar[NUM_PASOS];  //array ficticio para salvar simultaneidad
boolean paso_virgen [NUM_PASOS];  //array para saber si es la primera vez que se resuelve el paso
const int DS = 20;                //delay de sensorea
int cursor = 0;                   //cursor para lcd
int mensaje_actual = 0;           //mensaje actual
boolean lcd_change = false;       //actualizar mensaje lcd
boolean hour_change = false;      //actualizar hora lcd
boolean orden_change = false;     //actualiza orden lcd
String hour;                      //hora actual
int tiempo_restante = 3600;       //tiempo restante de juego
unsigned long contador_tiempo = 0;//para el tiempo
unsigned long contador = 0;       //para el tiempo
unsigned long contador_botones = 0; //para los botones
int paso = 0;                     //estado del game
const char RESET = 'R';           //para avisar reset
const int UPD_ETH = 500;         //tiempo para update eth
boolean play = false;             //jugando o ordenando
int ir_uni = 0;                   //para saltear pasos por ir
int ir_dec = 0;                   //''
boolean ir_change = false;        //''
boolean er_ir_lcd = false;        //''
boolean lcd_start = false;        //para borrar pantalla de abajo al iniciar
boolean resuelto = false;         //si se gano el juego
boolean ret_next = false;
boolean ret_reset = false;
boolean saltea = false;
String mensaje_recibido;
//OBJETOS
EthernetClient ethClient;
PubSubClient client(ethClient);
LiquidCrystal_I2C lcd(0x3F, 16,2);                  //lcd
SoftwareSerial mySoftwareSerial(RX_ADF, TX_ADF);    // RX, TX
DFRobotDFPlayerMini myDFPlayer;                     //dfplayer
void printDetail(uint8_t type, int value);          //dfplayer

/**********************************SETUP*************************************/
void setup() 
{
  delay(1000);
  Serial.begin(9600);
  if (Ethernet.begin(mac) == 0) {
    Serial.println("Failed to configure Ethernet using DHCP");
  }
  client.setServer(mqtt_server, puerto_server);
  client.setCallback(callback);
  delay(1000);                                                   //delay inicial
  Serial.println("Inicio");
  lcd.begin();                                                   //init LCD
  if (!myDFPlayer.begin(mySoftwareSerial)) {                     //Arranca dfplayer
    Serial.println(F("Unable to begin:"));
    Serial.println(F("1.Please recheck the connection!"));
    Serial.println(F("2.Please insert the SD card!"));
    Serial.println(myDFPlayer.readState()); //read mp3 state
    Serial.println(myDFPlayer.readFileCounts()); //read all file counts in SD card
  }
  llena_arrays(); //llena los arrays de inicio
  dec_sensores_reles();//declara sensores y reles
  lcd.setCursor(0,0); //muestra mensaje de bienvenida
  lcd.print(MENSAJES_LCD[0]);
  lcd.setCursor(0,1);
  lcd.print(MENSAJES_LCD[1]);
}

/**********************************LOOP**************************************/
void loop() 
{
  BOTONES();
  LCD();
  eth_update();
  if(play){
    reloj();
    secuenciar();   
    }
}

/************************FUNCIONES_NO_EDITABLES_CORES******************************/

//Lee Botones
void BOTONES (){
  if(millis() - contador_botones >= DELAY_BOTON){
    if(check(0,BOTON_RESET,DS)){if(play){reset();}else{play = true;lcd_change=true;mensaje_actual = 3;}contador_botones = millis();}
    if(check(0,BOTON_NEXT,DS)){saltea = true;contador_botones = millis();}
  }
}

//recive y procesa el lcd
void LCD () 
{
  if(lcd_change){
      lcd.setCursor(0,0);
      lcd.print(MENSAJES_LCD[mensaje_actual]);
      lcd_change = false;
      if(resuelto){lcd.setCursor(0,1);lcd.print("                ");lcd.setCursor(0,1);lcd.print(hour);}
    }
  if(hour_change){
      lcd.setCursor(9,1);
      lcd.print(hour);
      hour_change = false;
    }
  if(ir_change){
    if(er_ir_lcd){
      lcd.setCursor(0,1);
      lcd.print("             ");
      er_ir_lcd = false;
      ir_change = false;
      }
    else{
      char num [2]= {48 + ir_dec,48 + ir_uni};
      String prnt = num;
      lcd.setCursor(0,1);
      lcd.print(prnt);    
      ir_change = false;
      }
    }
  if(orden_change){
      lcd.setCursor(0,0);
      lcd.print(MENSAJES_LCD[2]);
      lcd.setCursor(0,1);
      lcd.print(MENSAJES_LCD[1]);
      orden_change = false;      
    }
    if(lcd_start){
      lcd.setCursor(0,1);
      lcd.print("                ");
      lcd_start = false;      
    }
}

//acutaliza la red
void eth_update()
{ 
  if ((millis() - contador) >= UPD_ETH) {
    if (!client.connected()) {
      Serial.print("Connecting ...");
      if (client.connect("main_01")) {
        Serial.println("connected");
        client.subscribe(topicName);
      } 
    }
    if(play){ 
      if(PASOS_SIMULTANEOS[paso] == 0){client.publish(topicName, paso+48 );}
      else{
        int sim = PASOS_SIMULTANEOS[paso];
        int cont = 0;
        while(cont <= sim){
          if(estado_act[paso+cont] == false){client.publish(topicName, paso+48 );}
          cont++;  
        }
      }
    }else{client.publish(topicName, RESET );}
    contador = millis();
    client.loop();
  }
}

//reloj
void reloj()
{
  if ((millis() - contador_tiempo) >= 1000 && resuelto == false && paso > 0) {        //
     contador_tiempo = millis();
     if(tiempo_restante != 0){
        tiempo_restante = tiempo_restante - 1;
     }
     int min_sex = tiempo_restante / 60;
     int seg_sex = tiempo_restante - min_sex*60;
     int min_dec = min_sex/10;
     int min_uni = min_sex-min_dec*10;
     int seg_dec = seg_sex/10;
     int seg_uni = seg_sex-seg_dec*10;
     char toString[5];
     toString[0]=min_dec + 48;
     toString[1]=min_uni + 48;
     toString[2]=':';
     toString[3]=seg_dec + 48;
     toString[4]=seg_uni + 48;
     hour = toString;
     hour_change = true;
  }  
}

/************************FUNCIONES_NO_ESITABLES_SUP**************************/
//callback propio del MQTT
void callback(char* topic, byte* payload, unsigned int length) 
{
  Serial.print("Message arrived [");
  Serial.print(topic);
  Serial.print("] ");
  int i=0;
  for (i=0;i<length;i++) {
    Serial.print((char)payload[i]);
  }
  Serial.println();
}
//declara sensores y reles
void dec_sensores_reles ()
{
  int a = 0;
  while(a < SENSORES_NUM){
    pinMode(SENSORES_POS[a] , INPUT);
    digitalWrite(SENSORES_POS[a] , SENSORES_PULL[a]);
    a++;
    }
  a = 0;
  while(a < RELE_NUM){
    pinMode(RELE_POS[a] , OUTPUT);
    digitalWrite(RELE_POS[a] , HIGH);
    a++;
    }
  pinMode(BOTON_RESET , INPUT);
  digitalWrite(BOTON_RESET , HIGH);
  pinMode(BOTON_NEXT , INPUT);
  digitalWrite(BOTON_NEXT , HIGH);
}

//llena arrays iniciales
void llena_arrays ()
{
  int a = 0;
  while(a < NUM_PASOS){
    estado_act [a] = false;
    a++;
  }
  a = 0;
  while(a < NUM_PASOS){
    paso_virgen [a] = true;
    a++;
  }
  a = 0;
  int b = 0;
  while(a < NUM_PASOS){
    if(TIPO_PASOS[a] == IMAN){
      sensores_check_lugar[a] = b ;
      b++;}
    else{sensores_check_lugar[a] = -1;}
    a++;
  }
}

//checkea si se resolvieron los pasos simultaneos
boolean sim_check (int sim)
{
  if(sim!=0){
    int total = 0;
    int lugar = 0;
    while(lugar <= sim){
      if(paso_virgen[lugar+paso] == false){total++;}
        lugar++;
    }
    if(total == sim+1){return true;}
    else{return false;}}
  else{return false;}
}
//resuelve imanes
void paso_imanes (int paso)
{//delay(1000);
  if(TIPO_PASOS[paso] == IMAN){//for(int c = 0;c < SENSORES_NUM ;c++){Serial.println(digitalRead(SENSORES_POS[c]));}
    int a = sensores_check_lugar[paso];/*Serial.print("SENSOR ACTUAL :");Serial.println(digitalRead(SENSORES_POS[sensores_check_lugar[paso]])); */
    if(check(HOW_TO_CHECK[a] , SENSORES_POS[a] , DS) == true){
        set_paso(paso);
      }
    }
}
//actualiza pasos
void set_paso (int Paso){
  estado_act[Paso] = true;
  }
//comprueba el estado de un sensor
boolean check (boolean cual, int entrada, int ds)
{
  boolean resu = false;
  int contador = 0;  
  if(cual){ while(digitalRead(entrada) == 1 && resu == false){delay(ds);contador++;if(contador == 5){resu = true;}}
  }else{    while(digitalRead(entrada) == 0 && resu == false){delay(ds);contador++;if(contador == 5){resu = true;}}}  
  return resu; 
}

//resetea
void reset()
{
  llena_arrays();
  dec_sensores_reles ();
  play = false;
  paso = 0;
  orden_change = true;
  tiempo_restante = 3600;
  resuelto = false;
  digitalWrite(34, LOW);
  digitalWrite(35, HIGH);
  myDFPlayer.pause();
}
/*************************FUNCIONES_EDITABLES********************************/

//secuencia usa sim_check
void secuenciar()
{
  if(play){
    int sim = PASOS_SIMULTANEOS[paso];
    int act = 0;
    while(act <= sim){ 
      paso_imanes(paso+act);
      /*if (paso+act == PASO_ANA){if(analog() < 50){set_paso(PASO_ANA);}}*///AL MOMENTO DEBE CREARSE UNA FUNCION ANALOG POR PASO ANALOG
      if(estado_act[paso+act]){
        switch(paso+act){
      
          case 0:
            if(paso_virgen[paso+act]){   //PUERTA
              paso_virgen[paso+act] = false;
              paso++;
              mensaje_actual = 4;
              lcd_change = true;
              lcd_start = true;
              //ACA VA LO QUE CAMBIA EL PASO , RELES ETC, RECORDAR HACER PASO++ EN EL MOMENTO INDICADO
              digitalWrite(RELE_POS[0],LOW);
              myDFPlayer.loop(1);
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break;
    
          case 1:
            if(paso_virgen[paso+act]){    //SILLA
              paso_virgen[paso+act] = false;
              mensaje_actual = 5;
              lcd_change = true;
              paso++;
              //ACA VA LO QUE CAMBIA EL PASO
              digitalWrite(RELE_POS[9],LOW);
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break;
            
          case 2:
            if(paso_virgen[paso+act]){    //LAVARROPAS
              paso_virgen[paso+act] = false;
              mensaje_actual = 6;
              lcd_change = true;
              paso++;
              //ACA VA LO QUE CAMBIA EL PASO
              digitalWrite(RELE_POS[2],LOW);
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break; 
              
          case 3:
            if(paso_virgen[paso+act]){    //TABLERO
              paso_virgen[paso+act] = false;
              mensaje_actual = 7;
              lcd_change = true;
              //ACA VA LO QUE CAMBIA EL PASO
              myDFPlayer.play(2);
              digitalWrite(RELE_POS[12],HIGH);
              delay(1500);
              digitalWrite(RELE_POS[12],LOW);
              delay(200);
              digitalWrite(RELE_POS[12],HIGH);
              delay(200);
              digitalWrite(RELE_POS[12],LOW);
              delay(200);
              digitalWrite(RELE_POS[12],HIGH);
              delay(200);
              digitalWrite(RELE_POS[12],LOW);
              delay(200);
              digitalWrite(RELE_POS[12],LOW);
              digitalWrite(RELE_POS[3],LOW);
              paso++;
              myDFPlayer.loop(3);
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break;
            
          case 4:
            if(paso_virgen[paso+act]){    //TECLADO
              paso_virgen[paso+act] = false;
              mensaje_actual = 8;
              lcd_change = true;
              //ACA VA LO QUE CAMBIA EL PASO
              paso++;
              myDFPlayer.play(4);
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break;    

          case 5:
            if(paso_virgen[paso+act]){    //CHIMENEA
              paso_virgen[paso+act] = false;
              mensaje_actual = 9;
              lcd_change = true;
              //ACA VA LO QUE CAMBIA EL PASO
              paso++;
              digitalWrite(RELE_POS[5],LOW);
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break; 
              
          case 6:
            if(paso_virgen[paso+act]){   //MASCARAS 
              paso_virgen[paso+act] = false;
              mensaje_actual = 10;
              lcd_change = true;
              //ACA VA LO QUE CAMBIA EL PASO
              paso++;
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break;
            
          case 7:
            if(paso_virgen[paso+act]){    //PORTERO
              paso_virgen[paso+act] = false;
              mensaje_actual = 11;
              lcd_change = true;
              //ACA VA LO QUE CAMBIA EL PASO
              digitalWrite(RELE_POS[6],LOW);
              paso++;
              myDFPlayer.loop(6);
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break;
            
          case 8:
            if(paso_virgen[paso+act]){    //LINTERNA
              paso_virgen[paso+act] = false;
              mensaje_actual = 12;
              lcd_change = true;
              //ACA VA LO QUE CAMBIA EL PASO
              digitalWrite(35, LOW);
              paso++;
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD
                }
              }
            break;

          case 9:
            if(paso_virgen[paso+act]){    //BARRETA
              paso_virgen[paso+act] = false;
              mensaje_actual = 13;
              lcd_change = true;
              //ACA VA LO QUE CAMBIA EL PASO
              resuelto = true;
              digitalWrite(RELE_POS[7],LOW);
              resuelto = true;
              if(sim_check(sim)){
                //ACA VA LO QUE CAMBIA LA SIMULTANEIDAD

                }
              }
            break;
        }
      }else{if(saltea){set_paso(paso+act);saltea=false;}}
    act++;
    
    }

  }    
}

